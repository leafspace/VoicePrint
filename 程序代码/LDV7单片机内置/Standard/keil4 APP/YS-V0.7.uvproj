# Keil uVision project YS-V0.7.uvproj, settings and files
target YS-V0.7口令模式工程+IO控制 (MCS-51)
  device: STC10F12XE STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(45000000) MODP2
  output: V07C +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\user
  group APP
    ../code/: SourceMain.c
    ../code/ASRBasic/: LDChip.c Reg_RW.c MainCommon.c
    ../code/UserKeyword/: CommonKeyword.c
  group Driver
    ../user/: usart.c
